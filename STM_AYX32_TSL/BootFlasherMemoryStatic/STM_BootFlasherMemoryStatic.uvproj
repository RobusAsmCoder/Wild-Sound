# Keil uVision project STM_BootFlasherMemoryStatic.uvproj, settings and files
target BootFlasherMemoryStatic (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM_BootFlasherMemoryStatic +hex
  AfterMake: ..\TMT\HEXEROK\HEXEROK.exe
  c flags: Optim=1 OneElfS=1
  c define: VECT_TAB_SRAM,BOOTFLASHER_LOG=0
  c misc: --c99
  c include: .\SRC;..\SRC;..\SRC\LIB;..\SRC\LIB\inc;..\SRC\BootFlasher
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x800
  memory RVCT9: RAM 0x20000800 size 0x1f800
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group SRC
    ./SRC/: main.c
  group LIB
    ../SRC/LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SRC EXTERNAL
    ../SRC/: rb_base64m.c rb_crc16.c core_UID.c cortex_rb_sys.c rb_fifo.c rb_util.c
  group BootFlasher
    ../SRC/: BootFlasherF4.c
