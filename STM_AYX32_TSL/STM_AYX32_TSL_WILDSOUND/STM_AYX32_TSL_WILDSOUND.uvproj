# Keil uVision project STM_AYX32_TSL_WILDSOUND.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM_AYX32_TSL_WILDSOUND +hex
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  c include: .\SRC;.\SRC\HARDWARE;..\SRC\LIB\inc;..\SRC\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM_AYX32_TSL_WILDSOUND.sct
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group SRC
    ./SRC/: ChipAY_DigitalSample.c ChipAY_DigitalPlayer.c process.c ChipAY_Test.c TestCase.c main.c ChipAY_BootFlasher.c ChipAY_WS_Process.c MemoryAllocator.c
  group SRC_MAX_SPEED
    ./SRC/: ChipAY_StreamData.c ChipAY.c ChipAY_Interrupt.c ChipAY_Hardware.c ChipAY_WildSound.c ChipAY_Main.c
  group SRC_EX
    ../SRC/: BootFlasherF4.c
  group SRC_EX_MAX_SPEED
    ../SRC/: rb_crc16.c core_UID.c rb_base64m.c rb_fifo.c rb_util.c cortex_rb_sys.c
  group LIB
    ../SRC/LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE
    ./SRC/HARDWARE/: hardware.c
  group HARDWARE_MAX_SPEED
    ./SRC/HARDWARE/: interface.c hdinterrupt.c hdports.c hdtimers.c
